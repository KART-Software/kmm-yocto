PYQT_MODULES:append = " QtWidgets"
