# Fix parallel make race condition causing link errors
PARALLEL_MAKE = "-j 1"
